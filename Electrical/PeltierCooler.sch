File: Electrical/PeltierCooler.sch (KiCad schematic (older format))
At the start: 45 parts

Commit message: Annotated schematic
Parts:
- gave numbers to parts that had none: 45
